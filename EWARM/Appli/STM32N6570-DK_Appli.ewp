# IAR project STM32N6570-DK_Appli.ewp, settings and files
configuration STM32N6570-DK_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32N6570-DK ST STM32N6570-DK
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 64
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx; TX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_SECURE=1; USE_BPP=16; LL_ATON_OSAL=LL_ATON_OSAL_BARE_METAL; LL_ATON_PLATFORM=LL_ATON_PLAT_STM32N6; LL_ATON_RT_MODE=LL_ATON_RT_ASYNC; LL_ATON_SW_FALLBACK; USE_FULL_LL_DRIVER; LL_ATON_DUMP_DEBUG_API; LL_ATON_OSAL=LL_ATON_OSAL_THREADX; LL_ATON_EB_DBG_INFO; LL_ATON_DBG_BUFFER_INFO_EXCLUDED=1
  ICCARM.CCIncludePath2: ../../Appli/TouchGFX/App; ../../Appli/TouchGFX/target/generated; ../../Appli/TouchGFX/target; ../../Appli/Core/InLc; ../../Appli/AZURE_RTOS/App; ../../Secure_nsclib; ../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../Middlewares/ST/threadx/common/inc; ../../Middlewares/ST/threadx/ports/cortex_m55/iar/inc; ../../Middlewares/ST/AI/Npu/Devices/STM32N6XX/; ../../Middlewares/ST/AI/Inc; ../../Middlewares/ST/AI/Npu/ll_aton; ../../Drivers/CMSIS/DSP/Include; ../../Drivers/CMSIS/Include; ../../Appli/Core/Inc; ../../Appli/X-CUBE-AI/App; ../../Appli/Middlewares/ST/touchgfx/framework/include; ../../Appli/TouchGFX/generated/fonts/include; ../../Appli/TouchGFX/generated/images/include; ../../Appli/TouchGFX/generated/videos/include; ../../Appli/TouchGFX/generated/texts/include; ../../Appli/TouchGFX/generated/gui_generated/include; ../../Appli/TouchGFX/gui/include; ../../Appli/TouchGFX/custom/include; ../../Appli/Middlewares/ST/STM32_ISP_Library/isp/Inc; ../../Appli/Middlewares/ST/STM32_ISP_Library/evision/Inc; ../../Appli/Middlewares/ST/STM32_ISP_Library/isp_param_conf; ../../Drivers/BSP/STM32N6570-DK; ../../Drivers/BSP/Components/Common; ../../Drivers/BSP/Components/imx335; ../../Drivers/BSP/Components/rk050hr18; ../../Appli/Middlewares/ST/lib_vision_models_pp/lib_vision_models_pp/Inc; ../../Appli/Middlewares/ST/stm32-mw-camera-main; ../../Appli/Middlewares/ST/stm32-mw-camera-main/sensors; ../../Appli/Middlewares/ST/stm32-mw-camera-main/sensors/imx335; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/include; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: TX_SINGLE_MODE_SECURE=1; TX_INCLUDE_USER_DEFINE_FILE
  AARM.AUserIncludes: ..\..\Appli\Core\Inc
  OBJCOPY.OOCOutputFile: STM32N6570-DK_Appli.hex
  ILINK.IlinkOutputFile: STM32N6570-DK_Appli.out
  ILINK.IlinkIcfFile: stm32n657xx_ROMxspi2.icf
  ILINK.IlinkAdditionalLibs: ../../Appli/Middlewares/ST/touchgfx/lib/core/cortex_m55/IAR9.x/touchgfx_core.a; ../../Appli/Middlewares/ST/STM32_ISP_Library/evision/Lib/libn6-evision-awb_iar.a; ../../Appli/Middlewares/ST/STM32_ISP_Library/evision/Lib/libn6-evision-st-ae_iar.a; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/NemaGFX/lib/core/cortex_m55/IAR9.x/nemagfx_core_release.a; ../../Appli/Middlewares/ST/touchgfx_components/gpu2d/TouchGFXNema/lib/cortex_m55/IAR9.x/touchgfx_nema_release.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx.s
  group Application/User/Appli/AZURE_RTOS/App
    ../../Appli/AZURE_RTOS/App/: app_azure_rtos.c
  group Application/User/Appli/Core
    ../../Appli/Core/Src/: ai_component.c app_postprocess.c app_threadx.c drv_imx335_camera.c main.c secure_nsc.c stm32n6xx_hal_msp.c stm32n6xx_hal_timebase_tim.c stm32n6xx_it.c tx_initialize_low_level.S
  group Application/User/Appli/custom
    ../../Appli/TouchGFX/custom/src/: AIThread.cpp BitmapManager.cpp CameraThread.cpp HwButtonCtrl.cpp IMX335CameraDriver.cpp thread_helper_c.cpp UTIL_Draw.cpp
  group Application/User/Appli/Lib
    ../../Middlewares/ST/AI/Lib/: NetworkRuntime1000_CM55_IAR.a
  group Application/User/Appli/TouchGFX/App
    ../../Appli/TouchGFX/App/: app_touchgfx.c
  group Application/User/Appli/TouchGFX/target
    ../../Appli/TouchGFX/target/: CortexMMCUInstrumentation.cpp KeySampler.cpp STM32TouchController.cpp TouchGFXGPIO.cpp TouchGFXHAL.cpp
  group Application/User/Appli/TouchGFX/target/generated
    ../../Appli/TouchGFX/target/generated/: HardwareMJPEGDecoder.cpp nema_hal.c OSWrappers.cpp STM32DMA.cpp TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp
  group Application/User/Appli/X-CUBE-AI/App
    ../../Appli/X-CUBE-AI/App/: network.c
  group Doc
    ../../Appli/X-CUBE-AI/App/: network_generate_report.txt
  group Drivers/BSP/STM32N6570-DK
    ../../Drivers/BSP/STM32N6570-DK/: stm32n6570_discovery.c stm32n6570_discovery_bus.c stm32n6570_discovery_lcd.c
  group Drivers/CMSIS
    ../../Appli/Core/Src/: system_stm32n6xx_s.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cacheaxi.c stm32n6xx_hal_cortex.c stm32n6xx_hal_crc.c stm32n6xx_hal_crc_ex.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_gpu2d.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_icache.c stm32n6xx_hal_jpeg.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c
  group generated/fonts
    ../../Appli/TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_24_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_24_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_24_4bpp.cpp Table_verdana_40_4bpp.cpp UnmappedDataFont.cpp VectorFontRendererBuffers.cpp
  group generated/gui_generated/camera_screen
    ../../Appli/TouchGFX/generated/gui_generated/src/camera_screen/: CameraViewBase.cpp
  group generated/gui_generated/common
    ../../Appli/TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group generated/gui_generated/containers
    ../../Appli/TouchGFX/generated/gui_generated/src/containers/: LightProgressContainerBase.cpp
  group generated/gui_generated/main_screen
    ../../Appli/TouchGFX/generated/gui_generated/src/main_screen/: MainViewBase.cpp
  group generated/gui_generated/menu_screen
    ../../Appli/TouchGFX/generated/gui_generated/src/menu_screen/: MenuViewBase.cpp
  group generated/images
    ../../Appli/TouchGFX/generated/images/src/: BitmapDatabase.cpp image_daytime.cpp image_daytime_time.cpp image_digit_window.cpp image_group293.cpp image_group_292.cpp image_LCD_Brightness_Adjustment.cpp image_light_on.cpp image_nightTime.cpp image_pass_180.cpp image_pass_2770.cpp image_setting_icon.cpp image_spanner_hammer_icon.cpp image_square_272.cpp SVGDatabase.cpp
  group generated/images/__generated
    ../../Appli/TouchGFX/generated/images/src/__generated/: image_alternate_theme_images_backgrounds_800x480_poly.cpp image_alternate_theme_images_widgets_button_regular_height_50_small_round_disabled.cpp image_alternate_theme_images_widgets_button_regular_height_50_small_round_pressed.cpp image_alternate_theme_images_widgets_button_regular_height_50_tiny_round_normal.cpp image_alternate_theme_images_widgets_button_regular_height_50_tiny_round_pressed.cpp image_icon_theme_images_hardware_keyboard_backspace_50_50_E8F6FB.svg.cpp
  group generated/texts
    ../../Appli/TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group gui/camera_screen
    ../../Appli/TouchGFX/gui/src/camera_screen/: CameraPresenter.cpp CameraView.cpp
  group gui/common
    ../../Appli/TouchGFX/gui/src/common/: FrontendApplication.cpp
  group gui/containers
    ../../Appli/TouchGFX/gui/src/containers/: LightProgressContainer.cpp
  group gui/main_screen
    ../../Appli/TouchGFX/gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group gui/menu_screen
    ../../Appli/TouchGFX/gui/src/menu_screen/: MenuPresenter.cpp MenuView.cpp
  group gui/model
    ../../Appli/TouchGFX/gui/src/model/: Model.cpp
  group Middlewares/ai/vision
    ../../Appli/Middlewares/ST/lib_vision_models_pp/lib_vision_models_pp/Src/: od_pp_yolov2.c vision_models_pp.c
  group Middlewares/camera
    ../../Appli/Middlewares/ST/stm32-mw-camera-main/: cmw_camera.c cmw_utils.c
  group Middlewares/camera/imx335
    ../../Appli/Middlewares/ST/stm32-mw-camera-main/sensors/: cmw_imx335.c
  group Middlewares/camera/imx335/driver
    ../../Appli/Middlewares/ST/stm32-mw-camera-main/sensors/imx335/: imx335.c imx335_reg.c
  group Middlewares/isp
    ../../Appli/Middlewares/ST/STM32_ISP_Library/isp/Src/: isp_algo.c isp_cmd_parser.c isp_conf.c isp_core.c isp_services.c isp_tool_com.c
  group Middlewares/ST/AI/Npu/Devices/STM32N6XX
    ../../Middlewares/ST/AI/Npu/Devices/STM32N6XX/: mcu_cache.c npu_cache.c
  group Middlewares/ST/AI/Npu/ll_aton
    ../../Middlewares/ST/AI/Npu/ll_aton/: ecloader.c ll_aton.c ll_aton_cipher.c ll_aton_dbgtrc.c ll_aton_debug.c ll_aton_lib.c ll_aton_lib_sw_operators.c ll_aton_n64.c ll_aton_osal_freertos.c ll_aton_osal_linux_bw.c ll_aton_osal_linux_uio.c ll_aton_osal_threadx.c ll_aton_profiler.c ll_aton_rt_main.c ll_aton_runtime.c ll_aton_stai_internal.c ll_aton_util.c ll_sw_float.c ll_sw_integer.c
  group Middlewares/threadx/Core
    ../../Middlewares/ST/threadx/common/src/: tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../../Middlewares/ST/threadx/ports/cortex_M55/iar/src/: tx_iar.c tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_secure_stack.c tx_thread_secure_stack_allocate.s tx_thread_secure_stack_free.s tx_thread_secure_stack_initialize.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s txe_thread_secure_stack_free.c
